# Keil uVision project TRANSMIT.uvprojx, settings and files
target TRANSMIT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TRANSMIT +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
  group Drivers/tm_stm32fxxx
    ../Drivers/tm_stm32fxxx/Src/: tm_stm32_adc.c tm_stm32_ahrs_imu.c tm_stm32_am2301.c tm_stm32_bmp180.c tm_stm32_bor.c tm_stm32_buffer.c tm_stm32_button.c tm_stm32_cpu_load.c tm_stm32_crc.c tm_stm32_dac.c tm_stm32_delay.c tm_stm32_disco.c tm_stm32_dma.c tm_stm32_dma2d_graphic.c tm_stm32_ds18b20.c tm_stm32_exti.c tm_stm32_fatfs.c tm_stm32_fft.c tm_stm32_filters.c tm_stm32_fonts.c tm_stm32_general.c tm_stm32_gpio.c tm_stm32_gps.c tm_stm32_hd44780.c tm_stm32_i2c.c tm_stm32_i2c_dma.c tm_stm32_id.c tm_stm32_iwdg.c tm_stm32_lcd.c tm_stm32_library_template.c tm_stm32_lis302dl_lis3dsh.c tm_stm32_mpu6050.c tm_stm32_mpu9250.c tm_stm32_nrf24l01.c tm_stm32_onewire.c tm_stm32_pvd.c tm_stm32_qspiflash.c tm_stm32_rcc.c tm_stm32_rng.c tm_stm32_rotary_encoder.c tm_stm32_rtc.c tm_stm32_sdram.c tm_stm32_spi.c tm_stm32_spi_dma.c tm_stm32_ssd1306.c tm_stm32_string.c tm_stm32_touch.c tm_stm32_touch_ft5336.c tm_stm32_touch_ts3510.c tm_stm32_usart.c tm_stm32_usart_dma.c tm_stm32_usb.c tm_stm32_usb_device.c tm_stm32_usb_device_cdc.c tm_stm32_usb_device_msc.c tm_stm32_usb_host.c tm_stm32_usb_host_hid.c tm_stm32_usb_host_msc.c
software components: CMSIS:CORE 4.3.0
